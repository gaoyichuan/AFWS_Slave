# Keil uVision project Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F204EA STC
  cpu: IRAM(0-0xFF) IROM(0-0xFF8) CLOCK(35000000)
  output: Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./code/: main.c init.c NRF24L01.c SPI.c delay.c bit.c receive.c ADC.c AFWS.c EEPROM.c I2C.c
